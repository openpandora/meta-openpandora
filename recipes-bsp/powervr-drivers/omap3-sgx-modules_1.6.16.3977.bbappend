# The 1st OpenPandora devices have 3530's not 3630's so overload.

TI_PLATFORM_omap3-pandora = "omap3430"
